options:
  parameters:
    author: Will Hedgecock
    copyright: Vanderbilt University
    generate_options: qt_gui
    id: prowess_test
    output_language: python
    title: PROWESS Top-Level Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: prowess_signal_generator_0
  id: prowess_signal_generator
  parameters:
    configuration: /path/to/config.json
  states: {}

connections:
- [prowess_signal_generator_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
